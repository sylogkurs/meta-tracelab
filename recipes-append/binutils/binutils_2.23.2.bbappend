FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://Replace-BFD-set-macros-with-static-inline-functions.patch"
